## tests/safety/testcase.yaml
```yaml
tests:
  cyberbrick_esc.safety:
    platform_allow: native_sim
    tags:
      - safety
```
